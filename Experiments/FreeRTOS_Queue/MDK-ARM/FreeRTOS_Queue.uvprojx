# Keil uVision project FreeRTOS_Queue.uvprojx, settings and files
target FreeRTOS_Queue (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(25000000) ELITTLE
  output: FreeRTOS_Queue +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;..\Application\Inc;..\..\..\BSP\Inc;..\..\..\Components\SHT30\Inc;..\BSP\Inc;..\..\..\Core\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Middlewares\FreeRTOS-Kernel\include;..\..\..\Middlewares\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup/CMSIS
    ../../../Core/Startup/: startup_stm32f407xx.s
    ../../../Core/Src/: system_stm32f4xx.c
    ../../../BSP/Src/: bsp_i2c.c
    ../../../Components/SHT30/Src/: sht30.c
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c
  group BSP
    ../BSP/Src/: bsp_experiment.c
  group Application
    ../Application/Src/: app_queue_experiment.c
  group FreeRTOS
    ../../../Middlewares/FreeRTOS-Kernel/: tasks.c queue.c list.c
    ../../../Middlewares/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group HAL
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
