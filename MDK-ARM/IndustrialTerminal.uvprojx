# Keil uVision project IndustrialTerminal.uvprojx, settings and files
target IndustrialTerminal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: IndustrialTerminal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Core\Inc;..\Application\Inc;..\BSP\Inc;..\Components\SHT30\Inc;..\Middlewares\Modbus\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\IndustrialTerminal.sct
  group Startup
    ../Core/Startup/: startup_stm32f407xx.s
  group CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group BSP
    ../BSP/Src/: bsp_modbus_time.c bsp_can_rx_queue.c bsp_can_link_test.c bsp_can_loopback.c bsp_i2c.c bsp_uart.c bsp_rs485.c bsp_system_diagnostics_record.c bsp_system_diagnostics.c bsp_system_timing.c bsp_system_watchdog.c
  group Modbus
    ../Middlewares/Modbus/Src/: mb_rtu.c
  group Components
    ../Components/SHT30/Src/: sht30.c
  group Application
    ../Application/Src/: app_modbus_registers.c app_modbus_service.c app_bringup.c app_uart_bringup.c app_sht30_bringup.c app_sht30_collector.c app_data_service.c app_snapshot_consumer.c app_snapshot_text_formatter.c app_diagnostic.c app_uplink_service.c app_can_protocol.c app_can_service.c app_rs485_service.c app_system_monitor.c app_watchdog_gate.c
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_can.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
